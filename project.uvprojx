# Keil uVision project project.uvprojx, settings and files
target master (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32G030C8Tx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.4.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32G030xx,USE_FULL_LL_DRIVER,USE_HAL_DRIVER,
  c include: .\SRC\libraries\CMSIS\Include;.\SRC\libraries\CMSIS;.\SRC\libraries\STM32G0xx_HAL_Driver\Inc;.\SRC\app\main;.\SRC\app\sys;.\SRC\bsp
  asm include: .\SRC\libraries\CMSIS\Include;.\SRC\libraries\STM32F4xx_StdPeriph_Driver\Inc;.\SRC\user;.\SRC\libraries\CMSIS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x2800
  memory RVCT9: RAM 0x20000000 size 0x8000
  group app/main
    ./SRC/app/main/: bsp.c main.c
  group bsp
    ./SRC/bsp/: gpio.c uart.c
  group fwlib
    ./SRC/libraries/STM32G0xx_HAL_Driver/Src/: stm32g0xx_ll_utils.c stm32g0xx_ll_spi.c stm32g0xx_ll_tim.c stm32g0xx_ll_i2c.c stm32g0xx_ll_gpio.c stm32g0xx_ll_usart.c stm32g0xx_ll_rcc.c stm32g0xx_hal.c stm32g0xx_hal_cortex.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c
  group cmsis
    ./SRC/libraries/CMSIS/: system_stm32g0xx.c startup_stm32g030xx.s
